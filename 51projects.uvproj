# Keil uVision project 51projects.uvproj, settings and files
target 51projects (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51projects +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\final_projects;.\src;.\src\app;.\src\drive;.\src\include
  group startup
    ./: STARTUP.A51
  group app
    ./src/app/: main.c adjustMode.c
  group driver
    ./src/drive/: uart.c ds18b20.c lcd1602.c ds1302.c ds1302delay.c buzzer.c motor.c key4_4.c ir.c
